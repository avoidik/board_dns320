## board/d-link/dns320/Kconfig
```kconfig
if TARGET_DNS320

config SYS_BOARD
	default "dns320"

config SYS_VENDOR
	default "d-link"

config SYS_CONFIG_NAME
	default "dns320"

endif
```
